# Keil uVision project ADC10samAVR.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F407VE STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: ADC10samAVR
  c flags: Optim=1
  c include: ..\_M_ADC(10samplesAvarage)
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Source Group 1
    ./: main.c initFunction.c startup_stm32f40_41xxx.s UserFunctions.c
    D:/ARM/Startup/ST/STM32F4xx/: system_stm32f4xx.c
