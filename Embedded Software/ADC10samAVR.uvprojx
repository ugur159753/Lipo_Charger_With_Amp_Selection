# Keil uVision project ADC10samAVR.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407VE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: ADC10samAVR
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c include: ..\_M_ADC(10samplesAvarage)
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Source Group 1
    ./: main.c initFunction.c startup_stm32f40_41xxx.s UserFunctions.c
    D:/ARM/Startup/ST/STM32F4xx/: system_stm32f4xx.c
software components: CMSIS:CORE 5.1.2
